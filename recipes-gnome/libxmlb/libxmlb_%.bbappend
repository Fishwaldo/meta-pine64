#needed to build qtwebengine (for the messed up pkgconfig depenedencies)
BBCLASSEXTEND = "native nativesdk"