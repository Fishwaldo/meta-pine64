ERDEPENDS_GLES2 = "mesa-pvr"