EXTRA_OEMESON += "-Diso_639_xml=${STAGING_DIR_TARGET}/usr/share/xml/iso-codes/iso_639.xml -Diso_3166_xml=${STAGING_DIR_TARGET}/usr/share/xml/iso-codes/iso_3166.xml"
