# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b1c6f8f0c2aad61af45524ba148fe90"
SRC_URI[sha256sum] = "bc228183f6e3c563ade71fd4c64784aa0c0a0e5e108ac04c055e9bcd9836bb86"
