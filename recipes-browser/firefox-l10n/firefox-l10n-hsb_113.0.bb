# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b80ad9528fdbfef7c951163db0e5607a"
SRC_URI[sha256sum] = "9a14eae682acd9044b4227adf33ec1d2e0e4ecad75791fecfd355871d27eb047"
