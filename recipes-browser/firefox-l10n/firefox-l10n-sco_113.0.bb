# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6595d2e4241b43543860ba6f4ab5b685"
SRC_URI[sha256sum] = "fc0d9bccc2f36c96a3840337f49dd205dcf30e5d2eb98a3aa79ffbc230fad256"
