# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "242e2f604bfcbd8202a137e58cecf9e3"
SRC_URI[sha256sum] = "7c274bc5c13c6e0b7b2e6674f1e2af791b81eceb0bd722ef5a80e921a97bd903"
