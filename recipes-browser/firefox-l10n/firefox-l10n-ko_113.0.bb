# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d9c9cb4461d79a4ecee4c59e9a2b27c"
SRC_URI[sha256sum] = "ce1295de439ca8476195ac7c4041608669705943c60e883f678a20f0cb7f58e6"
