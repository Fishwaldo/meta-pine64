# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3197140ec20206bbc1f2746aa82348cc"
SRC_URI[sha256sum] = "bf9e2e72dfcdb609064a0c0f503001f270257045b3f0b455470bccfbab0476b9"
