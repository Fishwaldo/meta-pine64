# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f04cc6342e96e7a069416a398d3145a"
SRC_URI[sha256sum] = "1aaef77af624cc62ea3678dd593d861cf7dbf9b1f4bfa1fc58ad7027fda646c7"
