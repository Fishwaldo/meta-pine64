# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ef277298afeec7177a864b0321d3c95"
SRC_URI[sha256sum] = "3cf5d445db71fd5f33446f1d0fbe9773c067a0947b0d33e159e77a728c6d262a"
