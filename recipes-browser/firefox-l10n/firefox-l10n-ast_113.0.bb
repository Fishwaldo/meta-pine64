# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3b16e4aa45a79a3df893f2b5c8b02da"
SRC_URI[sha256sum] = "2b84cea51df01c5959d1b1012f3ac2e411b9da26b2264b18b59553a814f3ef8e"
