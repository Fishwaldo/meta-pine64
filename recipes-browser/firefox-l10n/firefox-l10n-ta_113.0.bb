# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d10e4105342b6a11374cb89bf029ee1e"
SRC_URI[sha256sum] = "d9f184a76008b8d2be832086b1f53baea3eff988993fd683c5cb2bcd1d240f4f"
