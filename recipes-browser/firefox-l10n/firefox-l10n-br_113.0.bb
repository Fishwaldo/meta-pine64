# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6f0b4865fc1f28976b83262b6260529"
SRC_URI[sha256sum] = "0f3d153bde7f1a6afb2a598fe98e95c41f5d14f78191db7b353220557e40e5d5"
