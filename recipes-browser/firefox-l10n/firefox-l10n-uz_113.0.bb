# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ef1d659cf3faf14fa7fbd49fa8159fe"
SRC_URI[sha256sum] = "944cd12f408e49e0fd4bb79205f9ce9ee007b64d923a3c1d83c1e0cc7f494621"
