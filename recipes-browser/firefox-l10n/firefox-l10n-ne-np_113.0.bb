# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a56e1bec847ed87015e023d8b0f1e590"
SRC_URI[sha256sum] = "93e71b7dd69dec0d992829ecd7362369a8a2c6070900d93879693d4ea5a1ef32"
