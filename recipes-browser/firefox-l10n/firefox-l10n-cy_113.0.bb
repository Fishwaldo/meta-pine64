# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f785994640ab76c92718fbb99b187158"
SRC_URI[sha256sum] = "f6c3f8edc69a07692a8fba5ad37a04e46f246bb9e2f085da5a97caa024d19828"
