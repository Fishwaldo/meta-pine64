# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9f13d9204ec9dd96831e931575121c8"
SRC_URI[sha256sum] = "8b895a7879c8bb652ff56e390e0da4889a4774f30f1976f11b13afe8e7a72994"
