# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d00d50971c596f162284f4963b27e86"
SRC_URI[sha256sum] = "38021f594397a1078fb5be7d584a15dae70f9663681f6f33ef9d14f2a3b91d93"
