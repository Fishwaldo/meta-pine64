# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5278cabee5e27f4db7231fa4d5725c2"
SRC_URI[sha256sum] = "aabf6cef613b20f1fdecd91fcc347275a7c1bc0ef1d18e55e5a245bf6735818e"
