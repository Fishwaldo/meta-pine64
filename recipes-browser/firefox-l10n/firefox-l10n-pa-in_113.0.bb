# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21939700fe3ac52af8be0dc6ad24fd6d"
SRC_URI[sha256sum] = "0f14e9cee9d13549d418bde6fb20c2827297e673bea582ac1cf085b8d763861e"
