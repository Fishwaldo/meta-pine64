# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "121373183fa761358fd49421430af058"
SRC_URI[sha256sum] = "df0794bb5b2e78aec73ecdc779458e9a86f756b5e2f37acec6e227543dc1b3d0"
