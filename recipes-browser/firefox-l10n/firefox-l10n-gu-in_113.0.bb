# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af2540b60658b9e83cc40f651488e220"
SRC_URI[sha256sum] = "0f4f2eea09738aea94c0afec45f0bec34dbae9c4bd922634c82735d3a703f292"
