# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24582b02173ef84f61f50618efda8475"
SRC_URI[sha256sum] = "d0cb5f452064685162686ba49a7b4f5ec6998c726d415c72f178b2db4ef523e3"
