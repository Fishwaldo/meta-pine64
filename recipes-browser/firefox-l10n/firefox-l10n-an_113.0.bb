# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2dec9890e2f1a236c9fc4a251248ffd2"
SRC_URI[sha256sum] = "ee8d0193cfd2ed426044352d957026e91f31d6c1de680080e6d27ae08cf70ec1"
