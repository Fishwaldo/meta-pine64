# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f83ac1b070e182435ad6280352b1bc4e"
SRC_URI[sha256sum] = "da39e10a5598ab69b756872efcaad594fe52dda0e533e7a0d56ad1cdc8859a43"
