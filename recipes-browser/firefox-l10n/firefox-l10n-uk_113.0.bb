# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37ab560b07737ef3ce5833fbc1ffbe4b"
SRC_URI[sha256sum] = "7fd38252dd62fe45a732dd322e920ab90533d533f947322db80c48773262a827"
