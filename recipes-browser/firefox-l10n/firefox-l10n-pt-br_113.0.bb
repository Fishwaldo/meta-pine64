# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e8a8cbd1c408b17aa23ec47adecfa56"
SRC_URI[sha256sum] = "6a5fdeefc438825d60ad5f8ff14615de43c4a332f01c275e9c2a4a66dd5a4fdb"
