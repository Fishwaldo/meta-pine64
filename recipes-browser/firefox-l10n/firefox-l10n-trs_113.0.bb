# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e68a74690f4f063e0ca438e6e7cbc63"
SRC_URI[sha256sum] = "abf2d8a5d2c8736ffbede3844101a3bd9ea977a0dbca091c2b87871e3bbe96c3"
