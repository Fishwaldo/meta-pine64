# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfb564ef913b918af6c5ef05341dcf01"
SRC_URI[sha256sum] = "0bac15f959317aab370995793e585b331b181536b5b40cfcf59100b81a086f38"
