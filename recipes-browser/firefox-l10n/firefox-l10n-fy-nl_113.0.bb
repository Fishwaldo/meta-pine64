# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2158c4e5ddd939ab207d0ae68255d47b"
SRC_URI[sha256sum] = "8a17ed68d41be60e18ecbe2becff41912305e7fb86384b7d1fc89dd767fa21d5"
