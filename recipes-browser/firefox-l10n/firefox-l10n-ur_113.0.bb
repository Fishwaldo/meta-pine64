# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81f51f7b07add64461360245c1507fd2"
SRC_URI[sha256sum] = "01db872a78484ee2ed53060810ab46927572d4af92c727b0e03e5337ad2a6fa5"
