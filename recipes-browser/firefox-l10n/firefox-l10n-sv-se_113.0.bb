# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "987631fcc050dcf7977e41034cc57bf4"
SRC_URI[sha256sum] = "1294a7fdf7e36a3abb2b89222e97d4aaa6dcc2b36bff5319843a64122c692160"
