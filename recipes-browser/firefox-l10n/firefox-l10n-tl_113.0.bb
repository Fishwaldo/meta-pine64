# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4644eec7f107b3ff0d448dcef5dabb8e"
SRC_URI[sha256sum] = "fb754a736658035849341f2d01d1f48bb06b09c7f1ee9e6749e0580c7c9cb903"
