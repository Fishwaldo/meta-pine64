# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa075db6c33e6bd952bdd448224cf4bb"
SRC_URI[sha256sum] = "075b9a3867ddee26ad61441939b4d431329b9605bb86125b29e719e81a0a2c68"
