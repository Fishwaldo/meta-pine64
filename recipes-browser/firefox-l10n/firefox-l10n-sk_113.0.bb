# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "250f3aeea822c009d767dfa7d20e029b"
SRC_URI[sha256sum] = "54ec4111d38fd2c4ce4dbfbb86a4517466102d1fd871f6f4f73e4f8cf59a998e"
