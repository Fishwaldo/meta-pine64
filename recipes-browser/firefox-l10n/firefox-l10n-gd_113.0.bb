# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2056b092ce47f4bc4fa0e4427c3626fa"
SRC_URI[sha256sum] = "9e57d9348c392adfbb14debfc3aa474116007241109ca421a369ef5865cca480"
