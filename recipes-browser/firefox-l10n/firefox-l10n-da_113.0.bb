# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9687746d4a33aee27048212c6bb2ecb3"
SRC_URI[sha256sum] = "ca9c9f07abd3feec4dc6cd375f3a2c8841ee19bd69585c6d70ad950c18879adc"
