# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85c3269acd3231077477310e5a23b174"
SRC_URI[sha256sum] = "d36df7a481a96ab6ac74ba4cc33e0ee72e91caa2bfe55b97a17d9794d2a3c4e8"
