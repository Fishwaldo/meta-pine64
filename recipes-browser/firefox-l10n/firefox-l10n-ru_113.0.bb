# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dce85d45f38ab47fd1d15530243a3841"
SRC_URI[sha256sum] = "32d56004e40dc59240060f0eb84bb761a67f4545d73856775eac41c79c25fdec"
