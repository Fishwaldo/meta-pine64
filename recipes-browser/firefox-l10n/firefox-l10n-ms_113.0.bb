# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac66eaf3835a6332839633d96927ec6f"
SRC_URI[sha256sum] = "917fe99ea4ce119c418d52d071e6662c8cb9c6190939111142a1daabc4091fd0"
