# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9663cc21440dca7a0892bfa6d325ed83"
SRC_URI[sha256sum] = "891591bcde2190b87be25d5d57777608b8f8cea06d58c8a60d09d18809b42856"
