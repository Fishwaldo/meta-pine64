# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "069db716c46f6763e8a145d7a551287d"
SRC_URI[sha256sum] = "f2fdd09021e69566d750e34404866235f0f395ead48b36db35738192de557ad0"
