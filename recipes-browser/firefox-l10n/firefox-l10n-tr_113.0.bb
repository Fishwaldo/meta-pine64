# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a940317bb164be6409904c1e3dc5a21"
SRC_URI[sha256sum] = "30c5079f9c514b7b9e8bc44fd67bd44e4a5b42457c9c76a2ca606a8bf5d62bde"
