# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d3bdbf2a85518ef6fd4df39692bbed6"
SRC_URI[sha256sum] = "11729bfef6adcea46e77b1c96dc2b40d3989ffa36ba65f3782f9453f5533b2ae"
