# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "369ce9aeaf6700de5c31c3f658b234c4"
SRC_URI[sha256sum] = "ee2753898e65d344ad7bc9642ec0a2e05a7880ebee03112c1190cd001c15b4b9"
