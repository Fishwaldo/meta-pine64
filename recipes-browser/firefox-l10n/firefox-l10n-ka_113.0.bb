# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80db52168ca4524a5a28dded63c04875"
SRC_URI[sha256sum] = "fef917c385f92ac3dc95aff1d2e9f78eb7afe9d74895c87a7051d770ac887987"
