# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba98da166904c33ef73446d0c53fd95a"
SRC_URI[sha256sum] = "0373f78a7bbe79d849c11bec495893c5e99f40c20d3b674acb9704126cd49741"
