# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9c35d0466b5b56ad2bebd243303fd44"
SRC_URI[sha256sum] = "897f391a66e95dc41f52c480a162239f76bac3cf7209152e7e610a19facee29f"
