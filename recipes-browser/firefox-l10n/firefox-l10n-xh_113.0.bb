# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "559f0a336726c4b852a3aaff70f766a8"
SRC_URI[sha256sum] = "1da211f718c88aa8252be97c7a5703d54e9c65599a24121d80853174e9e7dd60"
