# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15a8963a902a614d7a8273b2a96d46ec"
SRC_URI[sha256sum] = "3f11b5ea15424f75544378a913eff10f2f9802610541aa24dca72ee2503ef35d"
