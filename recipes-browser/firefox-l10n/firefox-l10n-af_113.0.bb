# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfd5bec3f3b910cda22f6b54eac4182e"
SRC_URI[sha256sum] = "21d502f5e1d25ee0ea4b3709afc7e9575f629cd15737e21aed19c1f148fd57d1"
