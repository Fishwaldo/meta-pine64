# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f945b0f0d8bea0042d2b5f2cfaf08f6d"
SRC_URI[sha256sum] = "9f442e9e8c819791cb78fe655c53129b9a5d0b8090079ab74b45b7f7d1515a5b"
