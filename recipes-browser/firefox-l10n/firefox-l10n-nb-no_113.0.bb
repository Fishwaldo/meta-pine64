# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8aa5605cb719f270bf6685a4d17c385"
SRC_URI[sha256sum] = "dcd54b26247e4563d675c612ca7c471fd2588fe9beda9c077695a2f5a673cdde"
