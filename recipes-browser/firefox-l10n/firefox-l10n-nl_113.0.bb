# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f53ba4fb44381c742b4ff53da63bbd81"
SRC_URI[sha256sum] = "5ba8d4c71ff5b915e20d9d5eab5f57d2daf971cf1b3f0b12dc2fd25755bf6303"
