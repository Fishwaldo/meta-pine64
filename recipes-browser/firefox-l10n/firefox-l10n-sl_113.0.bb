# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5dc1fd9326fed03eb71baf036538025"
SRC_URI[sha256sum] = "353fb938fd4641fd65b10cf54d9f40f703cec74a3d5316126478903eec3f9435"
