# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a14dba15128791a1f7bd30470cbd4278"
SRC_URI[sha256sum] = "3729bcd73ccc966f0d73f7e32aadb2bfbb9559466c69550602bedad2a78bf500"
