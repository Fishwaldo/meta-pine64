# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "144a90ea7b7f05ef69842a76fd33214a"
SRC_URI[sha256sum] = "d489aeb8ca63f97778fa309d43529838349918414188dce598d29b20c59da533"
