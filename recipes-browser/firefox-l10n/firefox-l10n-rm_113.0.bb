# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b49eca3cd1fa5debdb48dfe55af01a03"
SRC_URI[sha256sum] = "fcf415b511a74d57b1cfa92a22eabd5e3bc30f42642c754e07c429b8caffc714"
