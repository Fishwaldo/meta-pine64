# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "772db8fc13a6fe210c7e0dc01509d679"
SRC_URI[sha256sum] = "c38edc9bfb0ac02bf4972811f50baa3cb237c1e7d626237b8c7c08d520e1246d"
