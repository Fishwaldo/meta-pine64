# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "742ab7e5653241f2b8d291c5fe416d48"
SRC_URI[sha256sum] = "afce22b71757920587de3ff5a5c12fe3dd7b53daf9110ffde6c09c69545edd0e"
