# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2115314fb5faad094f8566c5789db33"
SRC_URI[sha256sum] = "438efaaae1867ab1b37fe23283c2bfe666d73288c76f482f339bcdf27a4eb7dd"
