# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "446e763ff94a2ac04cd028eee79e79e3"
SRC_URI[sha256sum] = "c750bac67017e0784cf58fb06e92e2bc52688a16a3773825a1a6e0df84ef233a"
