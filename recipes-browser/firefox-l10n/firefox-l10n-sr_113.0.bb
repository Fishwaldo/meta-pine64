# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ea0eef48c9710589d5fed5c2d725eee"
SRC_URI[sha256sum] = "19a21659c6fb216e5d594ca35f62453de7ceaf88408a52444b40f8dc23d64f17"
