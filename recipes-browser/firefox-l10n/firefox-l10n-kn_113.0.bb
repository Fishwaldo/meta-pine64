# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36ba150201deda9c4fcebf1f18f5fae5"
SRC_URI[sha256sum] = "5a25567e3c83bc7a57d16df9f5f669fb1b4e90f5bf1c483280cac6a00e86537c"
