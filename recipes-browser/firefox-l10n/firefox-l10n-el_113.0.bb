# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ec6a37f3cbdd4212be06534017da3ca"
SRC_URI[sha256sum] = "6ae2fdf3c67a676112befb69b0c66709f2acadfeb1d7696315e331cd61dc96bf"
