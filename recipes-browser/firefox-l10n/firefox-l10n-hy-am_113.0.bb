# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4048475ca01b0064454675b058a06fd0"
SRC_URI[sha256sum] = "9f75ea79337d72287bf6738fb62f6f5abb0bd67e306c331ae1feb412ec160482"
