# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "356b5f3813987f56bc10d30b62906414"
SRC_URI[sha256sum] = "d52e1c96fa56d3bd8f152bb4b2e9c9a9e2edc2c4fad81869b1962b06ebb4c283"
