# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce62dbcf37ad41b6f7c7b523eb4b451f"
SRC_URI[sha256sum] = "4fe334dce9241ad92b93e09c66124d42841a1e724e359cbb0c50e6000f2f9fc5"
