# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc9552866932ce304745d5ac70dae6b9"
SRC_URI[sha256sum] = "9aaf343698c7666394b393154ffcf248d87d226fe577e5563afd2de602249c2f"
