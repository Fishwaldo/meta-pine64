# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2c19627c028d014b987d1fa6a46b879"
SRC_URI[sha256sum] = "c43a49feff2ffe483599e286631a2f3bbad61fe90182b8d0acd5468115590971"
