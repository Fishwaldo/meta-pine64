# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa2ba9edee48a074eb6b49ce386b6522"
SRC_URI[sha256sum] = "85be7ecde1bfeea1f1f477f2b808de51c74f01d2228966f31e60abe06279049e"
