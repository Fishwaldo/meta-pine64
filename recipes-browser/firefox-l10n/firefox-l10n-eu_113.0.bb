# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04e38f3fb009d047b751cf85a56a881f"
SRC_URI[sha256sum] = "a4a11e68fcd10aadd62b0cb10533ffd43a1c98a3e1db535e119cac0df5613f3a"
