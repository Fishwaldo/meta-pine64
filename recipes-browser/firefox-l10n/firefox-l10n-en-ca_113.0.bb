# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7f390234599905450c34a0301c0c645"
SRC_URI[sha256sum] = "998bd6ee63d6388c0631524992d7c4d050f8f005d37b0c593e531bfaf6a4a2d1"
