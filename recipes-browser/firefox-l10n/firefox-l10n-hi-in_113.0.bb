# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1995f03ed8adadd37781abae599c23c5"
SRC_URI[sha256sum] = "95c0605bffcef0d327830fa14aea895d54b4c18cc38122e49ce115c9a7afb47f"
