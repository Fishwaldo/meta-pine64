# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef24c44b7c29309abd5070ba0d938a71"
SRC_URI[sha256sum] = "a34e84cd85b434885ba7b7b5824b293d8a8a9f23cceb23f79a802236eb6dde1e"
