# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaf6b42804c781ee2d6c3267ef463b79"
SRC_URI[sha256sum] = "e1ea24d2cfa6fc4b490ac81755920b9b8f6f481666d56a66be6fde2539b2080d"
