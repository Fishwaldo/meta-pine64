# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "509c10514405cd6c26e5a46aa005f90f"
SRC_URI[sha256sum] = "fd42ffc5e14bd3526d8fea876a1e18df379e5f75c1f10368641dee1d6eebbb23"
