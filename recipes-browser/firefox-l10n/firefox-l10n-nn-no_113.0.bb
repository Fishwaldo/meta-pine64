# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4f4f59db6a29b85064752ecc59d5e95"
SRC_URI[sha256sum] = "6b6a82733fec2611d62fafc00dd3de8bc7f7018a8ea9c1f1f7f8d11b599e2a23"
