# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5a19e8ff88153ccf735b609dc9d49e1"
SRC_URI[sha256sum] = "ea9bf771e9e792a2a1723093c3f3d522681f638c5dc30c0dae6dde0a68648961"
