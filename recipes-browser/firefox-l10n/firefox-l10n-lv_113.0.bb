# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23493391de8e477a0588fb5a6f3b5db5"
SRC_URI[sha256sum] = "4afde707b110688d130a865969a5ebd78cc7876f74ac151624705fd9f3a8e275"
