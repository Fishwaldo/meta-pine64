# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c5a0cb78610d870e65889cf471c5421"
SRC_URI[sha256sum] = "b1938f51754971be1fa5fcccccdfcba6fa63a845746e47f666efd050042141c1"
