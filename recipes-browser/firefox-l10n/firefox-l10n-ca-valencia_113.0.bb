# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7daccbc8817abac84670b8be9200406d"
SRC_URI[sha256sum] = "156747a491aaf8744bd37a085a5b3959d1c00a4edac14ed859690cf980aae709"
