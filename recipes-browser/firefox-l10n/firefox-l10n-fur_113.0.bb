# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17423645448846144fc77fabe453e528"
SRC_URI[sha256sum] = "2881cc7ff05394ed995165fd9ca82dbbfd3450642128d69eb9b68671afc88f52"
