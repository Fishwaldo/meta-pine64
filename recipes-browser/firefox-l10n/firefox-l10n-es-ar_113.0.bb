# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee3509375d2b08ee5b32134921879b27"
SRC_URI[sha256sum] = "57400cd4597926629ab8f22e5f4722e0234f5727441906708786bbe6843fbf22"
