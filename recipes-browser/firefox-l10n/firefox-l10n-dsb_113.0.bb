# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94c1709194c9227eeda7e0fe74e96f73"
SRC_URI[sha256sum] = "b0a4b03cb247c8f0c87c9dee819cc47ff6ced32cb3c89773233a08963975ea36"
