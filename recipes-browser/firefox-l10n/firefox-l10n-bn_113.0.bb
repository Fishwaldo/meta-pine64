# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de889c1546a265f7fee46be621aed5ef"
SRC_URI[sha256sum] = "06144c4d43188e20d3325c2799a61b87808b587dc0136ac817d890a0cd91bf25"
