# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa42fd1d82964f7d1ee28b8473464385"
SRC_URI[sha256sum] = "bd31e4c6331cc249f114eb9ef7a454d99482fb05c0f0f0e8d4507948d7c113b5"
