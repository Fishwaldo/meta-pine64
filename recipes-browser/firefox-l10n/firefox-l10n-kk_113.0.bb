# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41c3d3773a546f44e82c8d140991311d"
SRC_URI[sha256sum] = "177164301e02565efb226aa525e5b5b2bfd7cd904f5456e15350284f31f3f223"
