# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0dd5a502dede32291647baebbd31c1ca"
SRC_URI[sha256sum] = "3626081b50619d66cb88e14eaf71caa97a2b48d79f69cac3a5bb919633f87d04"
