# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17b8f2003813736bf987e113c80e4c73"
SRC_URI[sha256sum] = "60db4ea466aa513ca24c4051f0c048bd09e6feb0935b7789cbe4331ad4888cdc"
