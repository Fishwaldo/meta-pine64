# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67ad2beacd47f09b60e015b5479f66b3"
SRC_URI[sha256sum] = "45310e7db684e38f404fc4b805e39bbe7a5bae4028beab38311e6aaf2a31fe2b"
