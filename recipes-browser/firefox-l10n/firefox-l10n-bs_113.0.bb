# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe5ac1d133d26d9b970ddba794acf2ed"
SRC_URI[sha256sum] = "a3ff7e5536d4ff85b06ca4f8ffacee45cf1ba73c0662593a14bac544139cc3f9"
