# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "094e5d4478439b16ce321f45874e3cb0"
SRC_URI[sha256sum] = "cc351cb54675a908b20226b13354e189b6a3fc38a5c039116b1f2258af0f479f"
