# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68d672ca3e375736d4e55fd1da17a234"
SRC_URI[sha256sum] = "8a8e4d03059b5bd2ed73870e89f31b20b6ef4d644487d2e048eb422f59a3649b"
