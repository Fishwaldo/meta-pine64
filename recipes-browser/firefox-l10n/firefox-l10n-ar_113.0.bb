# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9af1a85781086ad44e3a09e69064eed8"
SRC_URI[sha256sum] = "dca830694cccbecd46e74950d14fa46c3f43614551fb7f75e3b537275a9d50fa"
