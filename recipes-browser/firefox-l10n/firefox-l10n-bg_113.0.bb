# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1beb364d25946b242415e0cf55eb1ed9"
SRC_URI[sha256sum] = "6a6a2cc943c146a98180ed5e862a2c279a08702f89d4074beec01a64f55b98a1"
