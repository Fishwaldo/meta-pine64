# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4190efeaf3c5a9f18eaea4af922d04a2"
SRC_URI[sha256sum] = "26e0a1db066ec73688d607243f90c98b77806cd67bee504345f6de1e24915f4c"
