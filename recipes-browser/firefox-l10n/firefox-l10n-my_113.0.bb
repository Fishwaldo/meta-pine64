# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "461aad2054797a0072839373280e4b0e"
SRC_URI[sha256sum] = "8eafb1a687d8b8072c6caec83f9ca80d03699f0a182629c2087fe77c2f354fd2"
