# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ea0804247c996b9e87e286428401512"
SRC_URI[sha256sum] = "a7cb00209f94b3cb18db773f6d7ab568c416c3604b2d109135b9521f89e2371c"
