# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a7f0bf3b58ccdc40ea7325d501ae281"
SRC_URI[sha256sum] = "57c023667b616fcb8a017cddfcc74215b687bfbb9ae597bada4658979dbeb930"
