# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bb4b83f0442c8b11da14de48a140ee6"
SRC_URI[sha256sum] = "6bf5b9d2f30ded74ebdf32933148fe7a478cffff9353379b72f0482ea0991f10"
