# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "376630c0baf84c3bd8206c64e1ef8434"
SRC_URI[sha256sum] = "f9ebe4290302e434ac774cf21bd5397d438c9e6478b778bd2b2c2bd5f95c3399"
