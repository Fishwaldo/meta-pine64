# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed4e15890f34245ea0470395f3e27105"
SRC_URI[sha256sum] = "06acc903cfbb6b7f683ae738b733972e451ab6a14b28f7975c2884ae59701ec4"
