# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require recipes-playground/${BPN}.inc
SRCREV = "470f93dd00c619dedd41a85f0e53b035ff48d6b1"
