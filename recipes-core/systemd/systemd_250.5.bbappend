PACKAGECONFIG:remove = "networkd resolved nss-resolve"
PACKAGECONFIG:append = "coredump elfutils firstboot"
