PACKAGECONFIG:remove:jh7110 = "initrd"
PACKAGECONFIG:append:jh7110 = " drm "