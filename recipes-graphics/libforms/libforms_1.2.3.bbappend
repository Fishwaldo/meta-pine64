#original recipe is hardcoded to mesa
DEPENDS = "libxpm jpeg libx11 virtual/libgl"