#disable opengl
PACKAGECONFIG_GL=""

DEPENDS += " \
    virtual/egl \
"