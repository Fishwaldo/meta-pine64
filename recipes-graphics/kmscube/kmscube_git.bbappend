#depends on virtual/libgles3 in original reciepe
DEPENDS = "virtual/libgles2 virtual/egl libdrm virtual/libgbm"