PACKAGECONFIG += " gstreamer qt5 vorbis ogg x264 x11"

#DEPENDS += " \
#    wayland-native \
#"