PACKAGECONFIG:append = " \
    egl \
"