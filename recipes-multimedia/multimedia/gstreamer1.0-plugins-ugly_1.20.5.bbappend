PACKAGECONFIG:append = " \
    x264 \
"