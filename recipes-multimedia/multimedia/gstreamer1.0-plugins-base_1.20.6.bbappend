PACKAGECONFIG:append = " \
    opus \  
    qt5 \
"