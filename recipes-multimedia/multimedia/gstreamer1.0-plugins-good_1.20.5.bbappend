PACKAGECONFIG:append = " \
    qt5 \
    vpx \
    wavpack \
"