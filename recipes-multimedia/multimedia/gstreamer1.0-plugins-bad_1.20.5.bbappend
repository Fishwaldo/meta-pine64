PACKAGECONFIG:append = " \
    faac \
    libde265 \
    openh264 \
    openjpeg \
    opusparse \
    rtmp \
    v4l2codecs \
    va \
    webrtc \
    webrtcdsp \
    opencv \
"
