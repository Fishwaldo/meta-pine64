PACKAGECONFIG:append = " \
    libmpv \
    lua5 \
"

