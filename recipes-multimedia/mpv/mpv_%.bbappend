EXTRA_OECONF += " \
    --enable-libmpv-shared \
"