COMPATIBLE_HOST:riscv64 = ".*riscv64.*"FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fix-includes.patch"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

