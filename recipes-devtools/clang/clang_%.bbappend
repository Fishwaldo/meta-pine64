#need WebAssembly for Firefox
LLVM_TARGETS_TO_BUILD = "RISCV;X86;WebAssembly"
