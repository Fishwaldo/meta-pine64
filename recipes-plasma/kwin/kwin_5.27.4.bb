# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/kwin-5.27.4.tar.xz"
SRC_URI[sha256sum] = "58449053d64ce58227fee5ac3f099289bc133d2feb5e61f2c3e4cd74b7a9e6b4"

