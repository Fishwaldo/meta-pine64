DEPENDS:append = " \
    appstream \
    kuserfeedback \
"