SRC_URI:append:jh7110 = " \
    file://0001-Use-VisionFive2-specific-MESA-Fork.patch \
"

DEPENDS:append = " \
    appstream \
"