# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-desktop-5.27.4.tar.xz"
SRC_URI[sha256sum] = "b94f1cd5f121312268d757078041d83220556c90f73e895518fb19542ae3c800"

