#missing file
LIC_FILES_CHKSUM:remove = "file://COPYING;md5=5c213a7de3f013310bd272cdb6eb7a24"

LIC_FILES_CHKSUM = "file://LICENSES/GPL-3.0-only.txt;md5=49fc03046e56a282c0c743b5d3a55b7c"

FILES:${PN} += " \
    ${datadir}/kglobalaccel/ \
    ${datadir}/zsh/site-functions \
"