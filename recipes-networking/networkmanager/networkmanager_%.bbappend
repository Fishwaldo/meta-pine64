PACKAGECONFIG:append = "resolvconf"