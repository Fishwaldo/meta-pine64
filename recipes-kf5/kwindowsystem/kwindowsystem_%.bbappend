#The Cmake files include the sysroot directory to pipewire and spa, delete the actual sysroot from the path. 
inherit cmake_sysroot
