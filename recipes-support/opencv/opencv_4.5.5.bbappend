PACKAGECONFIG:append = " \
    dnn \
"