#wrong path in yocto-meta-kde
SRC_URI = " \
    git://code.qt.io/qt/qtfeedback.git;name=qtfeedback;branch=master;protocol=https \
"