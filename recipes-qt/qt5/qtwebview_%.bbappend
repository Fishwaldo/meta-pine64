COMPATIBLE_MACHINE:riscv64 = "(jh7110)"
