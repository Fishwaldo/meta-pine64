PACKAGECONFIG:append = " \
    qml-debug \
"