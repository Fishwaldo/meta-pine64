PACKAGECONFIG:remove = " \
    xcomposite-egl \
    xcomposite-glx \
"